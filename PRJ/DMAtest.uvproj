# Keil uVision project DMAtest.uvproj, settings and files
target DMAtest (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DMAtest +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: ..\CORE;..\STM32F10x_FWLib\inc;..\STM32F10x_FWLib\src;..\SYSTEM;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group LIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_dma.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c dma.c bsp_ov7725.c bsp_sccb.c
  group SYSTEM
    ../SYSTEM/: delay.c sys.c usart.c
